require linux-yocto-marvell-cn10xxx.inc

KBRANCH:marvell-cn10xxx = "v6.12/standard/octeon"
